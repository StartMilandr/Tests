# Keil uVision project IWDT_VE_91.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MDR1986BE91 Milandr
  pack: Keil.MDR1986BExx.1.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IWDT_VE_91
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\IWDT;..\src_brd;..\IWDT_VE_91
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../: main.c
    ../src_brd/: brdBKP.c brdBtn.c brdLed.c brdIWDT.c brdUtils.c
software components: Device:Startup_MDR1986BE9x 1.3.1, Drivers:IWDG 1.3.1, Drivers:PORT 1.3.1, Drivers:RST_CLK 1.3.1
